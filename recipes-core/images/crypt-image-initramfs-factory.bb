require crypt-image-initramfs.inc

PACKAGE_INSTALL = " \
		${INITRAMFS_COMMON_PACKAGES} \
		initramfs-init-factory \
		"
