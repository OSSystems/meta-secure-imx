inherit uboot-hab-sign
