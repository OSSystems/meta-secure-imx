FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
  file://0001-Allow-passing-a-Kernel-keyring-key-descriptor-in-PLA.patch \
"
